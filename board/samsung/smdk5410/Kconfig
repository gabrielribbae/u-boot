## board/samsung/smdk5410/Kconfig
```kconfig
if TARGET_SMDK5410

config SYS_BOARD
	default "smdk5410"

config SYS_VENDOR
	default "samsung"

config SYS_CONFIG_NAME
	default "smdk5410"

endif
```
